FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"

FILES:tzdata-core += " \
    ${datadir}/zoneinfo/Asia/Kolkata \
"
