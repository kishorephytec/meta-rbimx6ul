require rb-base-bundle.inc
RAUC_SLOT_rootfs ?= "rb-headless-image"
