require rb-base-bundle.inc
RAUC_SLOT_rootfs ?= "rb-qt5demo-image"
