FILESEXTRAPATHS_prepend := "${THISDIR}:"

COMPATIBLE_MACHINE = "ruggedboard-imx6ul"

SRC_URI += "file://0001-Support-for-RAUC-system-A-B-setup.patch \
"
