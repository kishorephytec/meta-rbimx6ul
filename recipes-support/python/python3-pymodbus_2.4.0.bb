inherit setuptools3
require python-pymodbus.inc
